# Keil uVision project ASM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TIMER +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\Motor;..\HARDWARE\Arm;..\HARDWARE\Measure;..\HARDWARE\Infrared;..\HARDWARE\Shoot;..\HARDWARE\KEY
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/KEY/: key.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/Infrared/: Infrared.c
    ../HARDWARE/Measure/: measure.c
    ../HARDWARE/Arm/: arm.c
    ../HARDWARE/Shoot/: Shoot.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group README
    ../: README.TXT
